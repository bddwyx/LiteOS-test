# Keil uVision project LiteOS.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GPIO
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: PART_TM4C1294NCPDT  __FPU_PRESENT RTOS_LOS
  c include: C:\ti\TivaWare_C_Series-2.2.0.295\driverlib;C:\ti\TivaWare_C_Series-2.2.0.295\inc;.\Drivers;.\Config;.\Application;.\LiteOS\arch\arm\arm-m\include;.\LiteOS\kernel\include;.\LiteOS\kernel\base\include;.\LiteOS\kernel\extended\include;.\LiteOS\OS_CONFIG;.\Drivers
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: .\Objects\GPIO.sct
  group Source Group 1
    ./: main.c
    C:/ti/TivaWare_C_Series-2.2.0.295/driverlib/rvmdk/: driverlib.lib
  group LiteOS/Arch
    ./LiteOS/arch/arm/arm-m/src/: los_hw.c los_hw_tick.c los_hwi.c
    ./LiteOS/arch/arm/arm-m/cortex-m4/keil/: los_dispatch_keil.S
  group LiteOS/Kernel
    ./LiteOS/kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ./LiteOS/kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ./LiteOS/kernel/base/mem/bestfit_little/: los_heap.c los_memory.c
    ./LiteOS/kernel/base/mem/common/: los_memcheck.c los_memstat.c los_slab.c los_slabmem.c
    ./LiteOS/kernel/base/mem/membox/: los_membox.c
    ./LiteOS/kernel/base/misc/: los_misc.c
    ./LiteOS/kernel/base/om/: los_err.c
    ./LiteOS/kernel/extended/tickless/: los_tickless.c
    ./LiteOS/kernel/: los_init.c
  group Drivers
    ./Drivers/: DigitalTube.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
